options:
  parameters:
    generate_options: no_gui
    id: fmrx
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '240000'
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '5'
    audio_pass: '16000'
    audio_stop: '20000'
    chan_rate: '240000'
    deviation: '75000'
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: /home/luke/radiostar/test.wav
    format: FORMAT_WAV
    samp_rate: '48000'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: '"rtl=200"'
    bb_gain0: '20'
    bw0: '200000'
    freq0: '88500000'
    gain0: '30'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_wavfile_sink_0, '0']
- [rtlsdr_source_0, '0', analog_fm_demod_cf_0, '0']

metadata:
  file_format: 1
